
FILESEXTRAPATHS_prepend := "${THISDIR}/cfg:"
 
SRC_URI_append = " file://kernel.cfg"