FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
 
SRC_URI:append = " file://avahi-daemon.conf"